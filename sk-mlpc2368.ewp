# IAR project sk-mlpc2368.ewp, settings and files
configuration Flash Post (ARM, debug)
  General.OGChipSelectEditMenu: LPC2368 NXP LPC2368
  General.RTConfigPath2: $TOOLKIT_DIR$\INC\c\DLib_Config_Normal.h
  General.CoreVariant: 1
  General.FPU2: 0
  ICCARM.CCDefines: BOARD_POST_CFG
  ICCARM.CCIncludePath2: OS\app; OS\bsp; OS\uc\cpu; OS\uc\lib; OS\uc\os_ii\port; OS\uc\os_ii\source; OS\uc\tcpip\IF\; OS\uc\tcpip\IF\Ether; OS\uc\tcpip\NIC\ETHER\LPC2368; OS\uc\tcpip\NIC\ETHER\PHY; OS\uc\tcpip\NIC\ETHER\PHY\KS8721BL; OS\uc\tcpip\OS; OS\uc\tcpip\Source; PROJECT; PROJECT\app; PROJECT\data; PROJECT\drivers; PROJECT\drivers\ccnet; PROJECT\drivers\fram; PROJECT\drivers\fiscal; PROJECT\drivers\keyboard; PROJECT\drivers\lcd; PROJECT\drivers\modem; PROJECT\services; PROJECT\libs; PROJECT\menu
  ICCARM.CCOptLevel: 1
  ICCARM.CCOptStrategy: 0
  ICCARM.IccLang: 0
  OBJCOPY.OOCOutputFile: sk_mlpc2368.hex
  ILINK.IlinkOutputFile: sk_mlpc2368.out
  ILINK.IlinkIcfFile: OS\bsp\LPC2368_Flash.icf
  ILINK.IlinkProgramEntryLabel: __iar_program_start
configuration Flash Central (ARM, debug)
  as the first configuration, except:
  General.RTConfigPath2: $TOOLKIT_DIR$\inc\c\DLib_Config_Normal.h
  ICCARM.CCDefines: BOARD_CENTRAL_CFG; CONFIG_FTP_CLIENT_ENABLE
  OBJCOPY.OOCOutputFile: changer0_31.hex
  ILINK.IlinkOutputFile: version0_14.out
configuration Flash Positive (ARM, debug)
  as the first configuration, except:
  ICCARM.CCDefines: BOARD_CENTRAL_CFG
  OBJCOPY.OOCOutputFile: sk_mlpc2368_positive_06_xx.hex
  ILINK.IlinkOutputFile: sk_mlpc2368_positive_06_xx.out
  group OS/app
    OS/app/: app.c app_cfg.h includes.h net_cfg.h os_cfg.h
  group OS/bsp
    OS/bsp/: bsp.c bsp.h cstartup.s iolpc2368.h LPC2368_Flash.icf LPC2368_Flash.mac net_bsp.c net_bsp.h net_isr.c
  group OS/uc/cpu
    OS/uc/cpu/: cpu.h cpu_a.s cpu_def.h
  group OS/uc/lib
    OS/uc/lib/: lib_def.h lib_mem.c lib_mem.h lib_str.c lib_str.h
  group OS/uc/os_ii/port
    OS/uc/os_ii/port/: os_cpu.h os_cpu_a.asm os_cpu_c.c os_dbg.c os_dcc.c
  group OS/uc/os_ii/source
    OS/uc/os_ii/source/: os_core.c os_flag.c os_mbox.c os_mem.c os_mutex.c os_q.c os_sem.c os_task.c os_time.c os_tmr.c ucos_ii.h
  group OS/uc/tcpip/Doc
    OS/uc/tcpip/Doc/: TCP-IP-Manual.pdf
  group OS/uc/tcpip/IF
    OS/uc/tcpip/IF/: net_if_pkt.c net_if_pkt.h
  group OS/uc/tcpip/IF/Ether
    OS/uc/tcpip/IF/Ether/: net_if.c net_if.h
  group OS/uc/tcpip/NIC/ETHER/LPC2368
    OS/uc/tcpip/NIC/ETHER/LPC2368/: net_nic.c net_nic.h net_nic_def.h
  group OS/uc/tcpip/NIC/ETHER/PHY
    OS/uc/tcpip/NIC/ETHER/PHY/: net_phy_def.h
  group OS/uc/tcpip/NIC/ETHER/PHY/DP83848
    OS/uc/tcpip/NIC/ETHER/PHY/DP83848/: net_phy.c net_phy.h
  group OS/uc/tcpip/NIC/ETHER/PHY/KS8721BL
    OS/uc/tcpip/NIC/ETHER/PHY/KS8721BL/: net_phy.c net_phy.h
  group OS/uc/tcpip/OS
    OS/uc/tcpip/OS/: net_os.c net_os.h
  group OS/uc/tcpip/Ports/ARM/IAR
    OS/uc/tcpip/Ports/ARM/IAR/: net_util_a.asm
  group OS/uc/tcpip/Source
    OS/uc/tcpip/Source/: net.c net.h net_arp.c net_arp.h net_ascii.c net_ascii.h net_bsd.c net_bsd.h net_buf.c net_buf.h net_cfg_net.h net_conn.c net_conn.h net_ctr.c net_ctr.h net_dbg.c net_dbg.h net_def.h net_err.c net_err.h net_icmp.c net_icmp.h net_ip.c net_ip.h net_sock.c net_sock.h net_stat.c net_stat.h net_tcp.c net_tcp.h net_tmr.c net_tmr.h net_type.h net_udp.c net_udp.h net_util.c net_util.h
  group PROJECT
    PROJECT/: version.h
  group PROJECT/app
    PROJECT/app/: app_serv.c app_serv.h console_cmd.c console_cmd.h control.c control.h ftp_app.c ftp_app.h host_app.c host_app.h journal.c journal.h modem_task.c modem_task.h
  group PROJECT/data
    PROJECT/data/: data.c data.h datadesc.c datadesc.h fram_map.h
  group PROJECT/drivers
    PROJECT/drivers/: uart.c uart.h
  group PROJECT/drivers/ccnet
    PROJECT/drivers/ccnet/: CCRSProtocol.c CCRSProtocol.h uart1.c uart1.h VMCConst.h
  group PROJECT/drivers/fiscal
    PROJECT/drivers/fiscal/: fiscal.c fiscal.h uart0.c uart0.h
  group PROJECT/drivers/fram
    PROJECT/drivers/fram/: fram.c fram.h spi.c spi.h
  group PROJECT/drivers/keyboard
    PROJECT/drivers/keyboard/: keyboard.c keyboard.h
  group PROJECT/drivers/lcd
    PROJECT/drivers/lcd/: lcd.c lcd.h symtab.h
  group PROJECT/drivers/modem
    PROJECT/drivers/modem/: modem.c modem.h uart2.c uart2.h
  group PROJECT/libs
    PROJECT/libs/: crc16.c crc16.h lpc23xx-iap.c lpc23xx-iap.h
  group PROJECT/menu
    PROJECT/menu/: menu.c menu.h menudesc.c menudesc.h
  group PROJECT/services
    PROJECT/services/: coin.c coin.h console.c console.h fr.c fr.h ftp_client.c ftp_client.h mode.c mode.h time.c time.h validator.c validator.h
